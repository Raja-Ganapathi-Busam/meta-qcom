PACKAGECONFIG:append:qcom = " ext-sw ml msgbroker"
